<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DFLZM_Dispenser.ewp</path>
  </project>
  <batchBuild />
</workspace>
